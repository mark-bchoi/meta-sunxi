
SRC_URI:append:orange-pi-one-plus = " file://enable_tracepoint.cfg \
            file://enable_kprobe.cfg"
SRC_URI:append:orange-pi-lite2 = " file://enable_tracepoint.cfg \
            file://enable_kprobe.cfg"
